<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\src\APP\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\APP\main.c</name>
    </file>
  </group>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\src\common\assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\common\io.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\common\memtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\common\printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\common\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\common\startup.c</name>
    </file>
  </group>
  <group>
    <name>cpu</name>
    <file>
      <name>$PROJ_DIR$\src\cpu\arm_cm0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\cpu\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\cpu\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\cpu\isr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\cpu\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\cpu\sysinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\cpu\system_SKEAZ1284.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\cpu\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\cpu\vectors.c</name>
    </file>
  </group>
  <group>
    <name>drivers</name>
    <file>
      <name>$PROJ_DIR$\src\drivers\adc\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\ftm\ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\gpio\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\gpio\GPIO_icf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\iic\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\ics\ics.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\kbi\kbi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\pit\pit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\sim\sim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\spi\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\uart\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\drivers\wdog\wdog.c</name>
    </file>
  </group>
  <group>
    <name>fun</name>
    <file>
      <name>$PROJ_DIR$\src\fun\fun.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\fun\fun.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\fun\OLED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\fun\OLED.h</name>
    </file>
  </group>
  <group>
    <name>platforms</name>
    <file>
      <name>$PROJ_DIR$\src\platforms\kea128_config.h</name>
    </file>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\user\headfile.h</name>
    </file>
  </group>
</project>


